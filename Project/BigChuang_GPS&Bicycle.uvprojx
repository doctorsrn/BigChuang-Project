# Keil uVision project BigChuang_GPS&Bicycle.uvprojx, settings and files
target MAIN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BigChuang_GPS&Bicycle
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\RTE\Device\STM32F103ZE;..\HardWare\usart;.\RTE;..\User\nmea_decode\include;..\User\GPS_Encoder;..\HardWare\TIMInte
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
    ../: readme.txt
    ../User/GPS_Encoder/: GPS_Encoder.c
  group Hardware
    ../HardWare/usart/: bsp_usart1.c bsp_usart2.c
    ../HardWare/TIMInte/: TIMINTE.c
  group nmealibrary
    ../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
